// German Latin supplement font - 14px DejaVu Sans
// Generated for U+00C4,U+00D6,U+00DC,U+00DF,U+00E4,U+00F6,U+00FC
// Bitmap data is a continuous 4bpp LVGL bitstream, with no row padding.

#include "lvgl.h"
#include <stddef.h>
#include <string.h>

#ifndef LV_ATTRIBUTE_LARGE_CONST
#define LV_ATTRIBUTE_LARGE_CONST
#endif

static LV_ATTRIBUTE_LARGE_CONST const uint8_t glyph_bitmap_latin_de_14[] = {
    0x00, 0x4f, 0x29, 0xc0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x03, 0xfc, 0x00, 0x00, 0x00, 0x09, 0xcf, 0x20, 0x00, 0x00, 0x1e, 0x4b, 0x80, 0x00, 0x00, 0x5d,
    0x05, 0xe0, 0x00, 0x00, 0xb7, 0x00, 0xe5, 0x00, 0x02, 0xf2, 0x00, 0x8b, 0x00, 0x08, 0xff, 0xff,
    0xff, 0x20, 0x0e, 0x50, 0x00, 0x0b, 0x70, 0x5f, 0x10, 0x00, 0x07, 0xd0, 0xab, 0x00, 0x00, 0x02,
    0xf4, 0x00, 0x08, 0xd0, 0xd8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x02, 0x9d, 0xfd, 0x92, 0x00, 0x02, 0xeb, 0x30, 0x2b, 0xe2, 0x00, 0xad, 0x00, 0x00,
    0x0d, 0xa0, 0x1f, 0x70, 0x00, 0x00, 0x7f, 0x13, 0xf5, 0x00, 0x00, 0x04, 0xf3, 0x3f, 0x50, 0x00,
    0x00, 0x4f, 0x31, 0xf7, 0x00, 0x00, 0x07, 0xf1, 0x0a, 0xd0, 0x00, 0x00, 0xda, 0x00, 0x2e, 0xb3,
    0x02, 0xae, 0x20, 0x00, 0x29, 0xdf, 0xe9, 0x20, 0x00, 0x00, 0x0e, 0x74, 0xf2, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x90, 0x00, 0x05, 0xf0, 0x0c, 0x90, 0x00,
    0x05, 0xf0, 0x0c, 0x90, 0x00, 0x05, 0xf0, 0x0c, 0x90, 0x00, 0x05, 0xf0, 0x0c, 0x90, 0x00, 0x05,
    0xf0, 0x0c, 0x90, 0x00, 0x05, 0xf0, 0x0b, 0xa0, 0x00, 0x06, 0xf0, 0x09, 0xd0, 0x00, 0x09, 0xc0,
    0x02, 0xf8, 0x11, 0x5e, 0x60, 0x00, 0x3b, 0xee, 0xc5, 0x00, 0x00, 0x7d, 0xec, 0x30, 0x00, 0x6e,
    0x31, 0x7d, 0x10, 0x0a, 0x90, 0x03, 0xf3, 0x00, 0xb8, 0x07, 0xd6, 0x10, 0x0b, 0x80, 0xf4, 0x00,
    0x00, 0xb8, 0x0f, 0x70, 0x00, 0x0b, 0x80, 0x7f, 0x80, 0x00, 0xb8, 0x00, 0x5e, 0xb0, 0x0b, 0x80,
    0x00, 0x3f, 0x20, 0xb8, 0x00, 0x07, 0xe0, 0x0b, 0x8a, 0xfe, 0xc4, 0x00, 0x00, 0xf6, 0x4f, 0x10,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9f, 0xfe, 0xb2, 0x00, 0x00, 0x00,
    0x19, 0xd0, 0x00, 0x00, 0x00, 0x0f, 0x30, 0x03, 0xae, 0xff, 0xf4, 0x00, 0xd9, 0x20, 0x0f, 0x50,
    0x2f, 0x20, 0x03, 0xf5, 0x00, 0xe8, 0x13, 0xcf, 0x50, 0x04, 0xdf, 0xd7, 0xe5, 0x00, 0x00, 0xba,
    0x1f, 0x50, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xef, 0xc4, 0x00,
    0x08, 0xd3, 0x18, 0xf2, 0x00, 0xf5, 0x00, 0x0c, 0x80, 0x2f, 0x20, 0x00, 0x9b, 0x03, 0xf2, 0x00,
    0x09, 0xb0, 0x0f, 0x50, 0x00, 0xc8, 0x00, 0x8d, 0x31, 0x7f, 0x20, 0x00, 0x8e, 0xfc, 0x40, 0x00,
    0x00, 0xab, 0x0f, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xc7, 0x00,
    0x0a, 0x90, 0x0c, 0x70, 0x00, 0xa9, 0x00, 0xc7, 0x00, 0x0a, 0x90, 0x0c, 0x70, 0x00, 0xa9, 0x00,
    0xc7, 0x00, 0x0a, 0x90, 0x0b, 0x80, 0x00, 0xc9, 0x00, 0x8d, 0x21, 0x7f, 0x90, 0x01, 0xae, 0xd9,
    0xa9, 0x00,
};

typedef struct LatinDeGlyphDsc_14 {
    uint32_t codepoint;
    uint32_t bitmap_index;
    uint8_t adv_w;
    uint8_t box_w;
    uint8_t box_h;
    int8_t ofs_x;
    int8_t ofs_y;
} LatinDeGlyphDsc_14;

static const LatinDeGlyphDsc_14 glyph_dsc_latin_de_14[] = {
    {0x00C4, 0, 10, 10, 13, 0, 0},
    {0x00D6, 65, 11, 11, 13, 0, 0},
    {0x00DC, 137, 10, 10, 13, 0, 0},
    {0x00DF, 202, 9, 9, 11, 0, 0},
    {0x00E4, 252, 9, 9, 11, 0, 0},
    {0x00F6, 302, 9, 9, 11, 0, 0},
    {0x00FC, 352, 9, 9, 11, 0, 0},
};

static const LatinDeGlyphDsc_14* find_latin_de_14_glyph(uint32_t codepoint) {
    for (size_t i = 0; i < sizeof(glyph_dsc_latin_de_14) / sizeof(glyph_dsc_latin_de_14[0]); i++) {
        if (glyph_dsc_latin_de_14[i].codepoint == codepoint) return &glyph_dsc_latin_de_14[i];
    }
    return NULL;
}

static bool latin_de_14_get_glyph_dsc(const lv_font_t* font, lv_font_glyph_dsc_t* dsc_out, uint32_t unicode, uint32_t unicode_next) {
    (void)font;
    (void)unicode_next;
    const LatinDeGlyphDsc_14* g = find_latin_de_14_glyph(unicode);
    if (!g) return false;
    memset(dsc_out, 0, sizeof(*dsc_out));
    dsc_out->adv_w = g->adv_w;
    dsc_out->box_w = g->box_w;
    dsc_out->box_h = g->box_h;
    dsc_out->ofs_x = g->ofs_x;
    dsc_out->ofs_y = g->ofs_y;
    dsc_out->bpp = 4;
    return true;
}

static const uint8_t* latin_de_14_get_glyph_bitmap(const lv_font_t* font, uint32_t unicode) {
    (void)font;
    const LatinDeGlyphDsc_14* g = find_latin_de_14_glyph(unicode);
    if (!g) return NULL;
    return &glyph_bitmap_latin_de_14[g->bitmap_index];
}

lv_font_t lv_font_latin_de_14 = {
    .get_glyph_dsc = latin_de_14_get_glyph_dsc,
    .get_glyph_bitmap = latin_de_14_get_glyph_bitmap,
    .line_height = 17,
    .base_line = 4,
    .subpx = LV_FONT_SUBPX_NONE,
    .underline_position = -1,
    .underline_thickness = 1,
    .dsc = NULL,
    .fallback = NULL,
};
