// German Latin supplement font - 10px DejaVu Sans
// Generated for U+00C4,U+00D6,U+00DC,U+00DF,U+00E4,U+00F6,U+00FC
// Bitmap data is a continuous 4bpp LVGL bitstream, with no row padding.

#include "lvgl.h"
#include <stddef.h>
#include <string.h>

#ifndef LV_ATTRIBUTE_LARGE_CONST
#define LV_ATTRIBUTE_LARGE_CONST
#endif

static LV_ATTRIBUTE_LARGE_CONST const uint8_t glyph_bitmap_latin_de_10[] = {
    0x00, 0xf2, 0xd0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5f, 0x30, 0x00, 0x0b, 0x79, 0x00, 0x02, 0xb0,
    0xc1, 0x00, 0x84, 0x07, 0x60, 0x0e, 0xff, 0xfc, 0x05, 0x90, 0x00, 0xc3, 0xb4, 0x00, 0x07, 0x90,
    0x00, 0x87, 0x96, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xae, 0xe9, 0x10, 0x0d, 0x81, 0x19, 0xb0,
    0x4c, 0x00, 0x00, 0xe2, 0x6a, 0x00, 0x00, 0xc4, 0x4c, 0x00, 0x00, 0xe2, 0x0d, 0x81, 0x19, 0xb0,
    0x02, 0xae, 0xe9, 0x10, 0x00, 0xc3, 0xd2, 0x00, 0x00, 0x00, 0x00, 0x2d, 0x00, 0x08, 0x72, 0xd0,
    0x00, 0x87, 0x2d, 0x00, 0x08, 0x72, 0xd0, 0x00, 0x87, 0x1e, 0x00, 0x09, 0x60, 0xd6, 0x13, 0xe3,
    0x03, 0xce, 0xd6, 0x00, 0x05, 0xde, 0x70, 0x0e, 0x31, 0xd1, 0x1d, 0x08, 0x92, 0x1c, 0x2b, 0x00,
    0x1c, 0x0c, 0x70, 0x1c, 0x01, 0x98, 0x1c, 0x00, 0x4c, 0x1c, 0x9f, 0xd5, 0x08, 0x7a, 0x50, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0xfe, 0x60, 0x00, 0x02, 0xc1, 0x1b, 0xef, 0xf3, 0x5b, 0x12,
    0xd3, 0x1c, 0xeb, 0xb3, 0x06, 0x97, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xee, 0x90,
    0x4d, 0x21, 0xb5, 0x68, 0x00, 0x68, 0x4d, 0x21, 0xb6, 0x07, 0xee, 0x90, 0x05, 0xa7, 0x80, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x2b, 0x00, 0x77, 0x2b, 0x00, 0x77, 0x2b, 0x00, 0x77, 0x1e, 0x22,
    0xc7, 0x08, 0xec, 0x97,
};

typedef struct LatinDeGlyphDsc_10 {
    uint32_t codepoint;
    uint32_t bitmap_index;
    uint8_t adv_w;
    uint8_t box_w;
    uint8_t box_h;
    int8_t ofs_x;
    int8_t ofs_y;
} LatinDeGlyphDsc_10;

static const LatinDeGlyphDsc_10 glyph_dsc_latin_de_10[] = {
    {0x00C4, 0, 7, 7, 9, 0, 0},
    {0x00D6, 32, 8, 8, 9, 0, 0},
    {0x00DC, 68, 7, 7, 9, 0, 0},
    {0x00DF, 100, 6, 6, 8, 0, 0},
    {0x00E4, 124, 6, 6, 8, 0, 0},
    {0x00F6, 148, 6, 6, 8, 0, 0},
    {0x00FC, 172, 6, 6, 8, 0, 0},
};

static const LatinDeGlyphDsc_10* find_latin_de_10_glyph(uint32_t codepoint) {
    for (size_t i = 0; i < sizeof(glyph_dsc_latin_de_10) / sizeof(glyph_dsc_latin_de_10[0]); i++) {
        if (glyph_dsc_latin_de_10[i].codepoint == codepoint) return &glyph_dsc_latin_de_10[i];
    }
    return NULL;
}

static bool latin_de_10_get_glyph_dsc(const lv_font_t* font, lv_font_glyph_dsc_t* dsc_out, uint32_t unicode, uint32_t unicode_next) {
    (void)font;
    (void)unicode_next;
    const LatinDeGlyphDsc_10* g = find_latin_de_10_glyph(unicode);
    if (!g) return false;
    memset(dsc_out, 0, sizeof(*dsc_out));
    dsc_out->adv_w = g->adv_w;
    dsc_out->box_w = g->box_w;
    dsc_out->box_h = g->box_h;
    dsc_out->ofs_x = g->ofs_x;
    dsc_out->ofs_y = g->ofs_y;
    dsc_out->bpp = 4;
    return true;
}

static const uint8_t* latin_de_10_get_glyph_bitmap(const lv_font_t* font, uint32_t unicode) {
    (void)font;
    const LatinDeGlyphDsc_10* g = find_latin_de_10_glyph(unicode);
    if (!g) return NULL;
    return &glyph_bitmap_latin_de_10[g->bitmap_index];
}

lv_font_t lv_font_latin_de_10 = {
    .get_glyph_dsc = latin_de_10_get_glyph_dsc,
    .get_glyph_bitmap = latin_de_10_get_glyph_bitmap,
    .line_height = 13,
    .base_line = 3,
    .subpx = LV_FONT_SUBPX_NONE,
    .underline_position = -1,
    .underline_thickness = 1,
    .dsc = NULL,
    .fallback = NULL,
};
