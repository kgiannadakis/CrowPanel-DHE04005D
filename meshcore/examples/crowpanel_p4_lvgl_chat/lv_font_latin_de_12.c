// German Latin supplement font - 12px DejaVu Sans
// Generated for U+00C4,U+00D6,U+00DC,U+00DF,U+00E4,U+00F6,U+00FC
// Bitmap data is a continuous 4bpp LVGL bitstream, with no row padding.

#include "lvgl.h"
#include <stddef.h>
#include <string.h>

#ifndef LV_ATTRIBUTE_LARGE_CONST
#define LV_ATTRIBUTE_LARGE_CONST
#endif

static LV_ATTRIBUTE_LARGE_CONST const uint8_t glyph_bitmap_latin_de_12[] = {
    0x00, 0x98, 0x5d, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0b, 0xe0, 0x00, 0x00, 0x02, 0xfd,
    0x50, 0x00, 0x00, 0x7a, 0x7b, 0x00, 0x00, 0x0d, 0x52, 0xf1, 0x00, 0x04, 0xe1, 0x0c, 0x70, 0x00,
    0x9a, 0x00, 0x7c, 0x00, 0x1e, 0xff, 0xff, 0xf3, 0x05, 0xe0, 0x00, 0x0b, 0x80, 0xb8, 0x00, 0x00,
    0x5e, 0x00, 0x00, 0x0f, 0x3b, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5c, 0xfe, 0x91, 0x00,
    0x6e, 0x51, 0x2b, 0xc0, 0x1e, 0x60, 0x00, 0x1e, 0x64, 0xf1, 0x00, 0x00, 0x9a, 0x5e, 0x00, 0x00,
    0x08, 0xb4, 0xf1, 0x00, 0x00, 0x9a, 0x1e, 0x60, 0x00, 0x1e, 0x60, 0x6e, 0x51, 0x2b, 0xc0, 0x00,
    0x6c, 0xfe, 0x91, 0x00, 0x00, 0x5d, 0x1f, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x40, 0x00,
    0x7b, 0x00, 0xe4, 0x00, 0x07, 0xb0, 0x0e, 0x40, 0x00, 0x7b, 0x00, 0xe4, 0x00, 0x07, 0xb0, 0x0e,
    0x40, 0x00, 0x7b, 0x00, 0xe4, 0x00, 0x07, 0xb0, 0x0c, 0x60, 0x00, 0x99, 0x00, 0x7d, 0x31, 0x4e,
    0x40, 0x00, 0x7d, 0xec, 0x50, 0x00, 0x01, 0xbe, 0xd5, 0x00, 0x0a, 0x91, 0x4e, 0x10, 0x0d, 0x30,
    0x4e, 0x30, 0x0e, 0x35, 0xc2, 0x00, 0x0e, 0x39, 0x70, 0x00, 0x0e, 0x36, 0xe3, 0x00, 0x0e, 0x30,
    0x7e, 0x60, 0x0e, 0x30, 0x04, 0xe0, 0x0e, 0x30, 0x05, 0xd0, 0x0e, 0x5f, 0xfd, 0x40, 0x04, 0xe0,
    0xf3, 0x00, 0x00, 0x00, 0x00, 0x0c, 0xff, 0xc3, 0x00, 0x00, 0x16, 0xd0, 0x00, 0x00, 0x0d, 0x20,
    0x6d, 0xff, 0xf4, 0x2e, 0x30, 0x0d, 0x43, 0xe2, 0x17, 0xf4, 0x08, 0xee, 0x9c, 0x40, 0x01, 0xf2,
    0xc6, 0x00, 0x00, 0x00, 0x00, 0x02, 0xbe, 0xd5, 0x00, 0xd8, 0x14, 0xe3, 0x3e, 0x00, 0x09, 0x85,
    0xc0, 0x00, 0x7a, 0x3e, 0x00, 0x09, 0x80, 0xd8, 0x14, 0xe3, 0x02, 0xbe, 0xd5, 0x00, 0x00, 0xf3,
    0xb7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x10, 0x08, 0x80, 0x0f, 0x10, 0x08, 0x80, 0x0f, 0x10,
    0x08, 0x80, 0x0f, 0x10, 0x08, 0x80, 0x0e, 0x20, 0x0a, 0x80, 0x0c, 0x81, 0x4e, 0x80, 0x03, 0xce,
    0xaa, 0x80,
};

typedef struct LatinDeGlyphDsc_12 {
    uint32_t codepoint;
    uint32_t bitmap_index;
    uint8_t adv_w;
    uint8_t box_w;
    uint8_t box_h;
    int8_t ofs_x;
    int8_t ofs_y;
} LatinDeGlyphDsc_12;

static const LatinDeGlyphDsc_12 glyph_dsc_latin_de_12[] = {
    {0x00C4, 0, 8, 9, 11, 0, 0},
    {0x00D6, 50, 9, 9, 11, 0, 0},
    {0x00DC, 100, 9, 9, 11, 0, 0},
    {0x00DF, 150, 8, 8, 10, 0, 0},
    {0x00E4, 190, 7, 7, 9, 0, 0},
    {0x00F6, 222, 7, 7, 9, 0, 0},
    {0x00FC, 254, 8, 8, 9, 0, 0},
};

static const LatinDeGlyphDsc_12* find_latin_de_12_glyph(uint32_t codepoint) {
    for (size_t i = 0; i < sizeof(glyph_dsc_latin_de_12) / sizeof(glyph_dsc_latin_de_12[0]); i++) {
        if (glyph_dsc_latin_de_12[i].codepoint == codepoint) return &glyph_dsc_latin_de_12[i];
    }
    return NULL;
}

static bool latin_de_12_get_glyph_dsc(const lv_font_t* font, lv_font_glyph_dsc_t* dsc_out, uint32_t unicode, uint32_t unicode_next) {
    (void)font;
    (void)unicode_next;
    const LatinDeGlyphDsc_12* g = find_latin_de_12_glyph(unicode);
    if (!g) return false;
    memset(dsc_out, 0, sizeof(*dsc_out));
    dsc_out->adv_w = g->adv_w;
    dsc_out->box_w = g->box_w;
    dsc_out->box_h = g->box_h;
    dsc_out->ofs_x = g->ofs_x;
    dsc_out->ofs_y = g->ofs_y;
    dsc_out->bpp = 4;
    return true;
}

static const uint8_t* latin_de_12_get_glyph_bitmap(const lv_font_t* font, uint32_t unicode) {
    (void)font;
    const LatinDeGlyphDsc_12* g = find_latin_de_12_glyph(unicode);
    if (!g) return NULL;
    return &glyph_bitmap_latin_de_12[g->bitmap_index];
}

lv_font_t lv_font_latin_de_12 = {
    .get_glyph_dsc = latin_de_12_get_glyph_dsc,
    .get_glyph_bitmap = latin_de_12_get_glyph_bitmap,
    .line_height = 15,
    .base_line = 3,
    .subpx = LV_FONT_SUBPX_NONE,
    .underline_position = -1,
    .underline_thickness = 1,
    .dsc = NULL,
    .fallback = NULL,
};
